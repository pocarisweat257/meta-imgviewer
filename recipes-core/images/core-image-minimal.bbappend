IMAGE_INSTALL:append = " myapp"
